options:
  parameters:
    generate_options: qt_gui
    id: wav_recording
    output_language: python
    title: Wav Recording
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: non-wav-recording.data
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: wav-recording.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}

connections:
- [audio_source_0, '0', blocks_file_sink_0, '0']
- [audio_source_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
