options:
  parameters:
    generate_options: qt_gui
    id: fmstream
    output_language: python
    title: fm stream
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '3'
  states: {}
- name: volume_slider
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.5'
    stop: '10'
    value: volume
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate * 4
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hendrik/Projects/radio/fm-stream/zitti-e-buoni.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '4000'
    type: ccc
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: 99.8e6
    samp_rate: 4e6
    type: fc32
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_sink_x_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
