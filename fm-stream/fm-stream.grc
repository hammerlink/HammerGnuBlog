options:
  parameters:
    generate_options: qt_gui
    id: fmstream
    output_language: python
    title: fm stream
  states: {}

blocks:
- name: file_name
  id: variable
  parameters:
    value: '"recording_2023_0_29.wav"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: recording_2023_07_29.wav
    writeback: None
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1'
  states: {}
- name: volume_slider
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.5'
    stop: '10'
    value: volume
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate * 4
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/hendrik/Projects/radio/fm-stream/non-wav-recording.data
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume_slider
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: recording_2023_07_29.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hendrik/Projects/radio/fm-stream/zitti-e-buoni.wav
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/hendrik/Projects/radio/fm-stream/zitti-e-buoni.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '4000'
    type: ccc
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: 99.8e6
    samp_rate: 4e6
    type: fc32
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', qtgui_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
