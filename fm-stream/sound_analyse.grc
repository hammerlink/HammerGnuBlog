options:
  parameters:
    generate_options: qt_gui
    id: sound_analyse
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: high_pass_495
  id: variable_high_pass_filter_taps
  parameters:
    cutoff_freq: '495'
    gain: '1.0'
    samp_rate: samp_rate
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_495
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '505'
    gain: '1.0'
    samp_rate: samp_rate
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: mute_box
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Mute sound
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: signal_volume
  id: variable_qtgui_range
  parameters:
    label: Signal Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: signal_volume
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.5'
    init: '0'
    low: '0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_495
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: high_pass_495
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    freqhalf: 'False'
    grid: 'True'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    freqhalf: 'False'
    nconnections: '2'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: raw_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fq_filter_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: raw_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fq_filter_signal
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [audio_source_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_1, '0']
- [fir_filter_xxx_0, '0', virtual_sink_1, '0']
- [fir_filter_xxx_0_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_1, '0', qtgui_number_sink_0, '0']
- [virtual_source_1, '0', qtgui_waterfall_sink_x_0, '1']

metadata:
  file_format: 1
